/************************************包含头文件*************************************************/
#include "type.h"
#include "bsp_adc.h"
#include "dl_power.h"


#ifdef _cplusplus
extern "C" {
#endif

/************************************函数实现**************************************************/
/********************************************************************************************
* 函数名称 :   dl_power_get_current_ma
* 功能描述 :   超容侧电流（mA，带符号，正 = 放电）
*
*               换算本身在 BSP 里（bsp_adc_get_so_ma），这里只做一次转发。
*               为什么不在 DL 里重算一遍：系数（GCSA、R_shunt）是板级常量，
*               放在 bsp_board.h / bsp_adc.c 一处就够，复制到 DL 只会多一个改漏的地方。
*
*               ⚠️ 精度限制见 dl_power.h 顶部：零点偏移等效 ±3.88 A，
*                  所以本函数返回 0 附近的值基本没有物理意义，
*                  别用它判断"是不是已经断流了"（BSP 的断电流程用的是 5 A 门限，
*                  就是为了盖住这个不确定度）。
*
* 输入参数 :   无
* 输出参数 :   无
* 返回值   :   电流（mA）
*********************************************************************************************/
S32 dl_power_get_current_ma
(
    VOID
)
{
    return bsp_adc_get_so_ma();
}

/********************************************************************************************
* 函数名称 :   dl_power_get_current_a
* 功能描述 :   超容侧电流（A），给需要浮点运算的地方用
* 输入参数 :   无
* 输出参数 :   无
* 返回值   :   电流（A）
*********************************************************************************************/
F32 dl_power_get_current_a
(
    VOID
)
{
    return ((F32)bsp_adc_get_so_ma()) / 1000.0F;
}

/********************************************************************************************
* 函数名称 :   dl_power_estimate_dump_mw
* 功能描述 :   估算泄放电阻上的平均功率（mW）
*
*               Pavg = D × V_bus² / R
*
*               推导：Q_DUMP 导通期间，外置电阻直接跨在 BUS 上，瞬时功率 V²/R；
*                     占空比 D 决定它有多大比例的时间导通 → 平均值就是上式。
*
*               ⚠️ 这是一个**下限估算**，漏掉了三样东西：
*                  1) MOSFET 的导通损耗（Rds(on) 与泄放电阻串联，会让实际功率略低）；
*                  2) 开关瞬间的电感/引线能量（会让瞬时功率更高）；
*                  3) 母线纹波 —— 用的是平均母线电压，而功率对电压是平方关系，
*                     纹波会让真实平均功率略高于按平均值算出来的数（Jensen 不等式）。
*                  所以拿这个数做热设计时要再留 20% 以上余量。
*
*               ⚠️ r_mohm 是**外置电阻**的阻值，原理图里只有 J_DUMP 连接器，
*                  没有具体型号。调用者传错这个数，功率估算就跟着错 ——
*                  而错误的功率估算会直接把电阻烧掉。
*
* 输入参数 :   bus_mv : 母线电压（mV）
*               duty   : 泄放占空比 0.0 ~ 1.0
*               r_mohm : 外置泄放电阻（mΩ）
* 输出参数 :   无
* 返回值   :   估算平均功率（mW），r_mohm 为 0 时返回 0
*********************************************************************************************/
U32 dl_power_estimate_dump_mw
(
    IN  U32     bus_mv,
    IN  F32     duty,
    IN  U32     r_mohm
)
{
    F32 v_v;
    F32 r_ohm;
    F32 power_w;

    if (r_mohm == 0U)
    {
        return 0U;
    }

    if (duty < 0.0F)
    {
        duty = 0.0F;
    }
    if (duty > 1.0F)
    {
        duty = 1.0F;
    }

    v_v   = ((F32)bus_mv) / 1000.0F;
    r_ohm = ((F32)r_mohm) / 1000.0F;

    power_w = duty * v_v * v_v / r_ohm;

    return (U32)((power_w * 1000.0F) + 0.5F);
}

#ifdef _cplusplus
}
#endif
